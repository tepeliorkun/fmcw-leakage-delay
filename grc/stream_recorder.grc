options:
  parameters:
    author: Orkun Alp Tepeli
    copyright: Captures IQ samples from ADALM-PLUTO SDR over the ECM USB interface. Samples are recorded to a binary file using a Timer block to control the recording duration. Useful for ECM vs RNDIS protocol performance comparison (e.g., sample loss, sustained bandwidth).
    generate_options: qt_gui
    id: Stream_recorder
    output_language: python
    title: tream_recorder
  states: {}

blocks:
- name: buffer_size
  id: variable
  parameters:
    value: int(200e3)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(6e6)
  states: {}
- name: sdr_LO_frequency
  id: variable
  parameters:
    value: int(2.48e9)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/orkun-alp/Documents/fmcw_bitirme_calismalari/radar_parameter/pluto_rndis_deneme_6Mhz_200k_1M.dat
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import time
      from gnuradio import gr

      class blk(gr.sync_block):  
          def __init__(self, duration=10):  
              gr.sync_block.__init__(
                  self, 
                  name='Timer',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.duration = duration
              self.pass_data = True

          def work(self, input_items, output_items):
              if not hasattr(self, "start_time"):
                  self.start_time = time.time()

              now = time.time()
              if now - self.start_time >= self.duration:
                  self.pass_data = False

              if self.pass_data:
                  output_items[0][:] = input_items[0]
                  return len(output_items[0])
              else:
                  return 0
    duration: '10'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(1e6)
    bbdc: 'True'
    buffer_size: buffer_size
    filter_source: '''Auto'''
    frequency: sdr_LO_frequency
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [epy_block_0, '0', blocks_file_sink_0, '0']
- [iio_pluto_source_0, '0', epy_block_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
