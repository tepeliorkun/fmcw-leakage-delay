options:
  parameters:
    author: Orkun Alp TEPELİ
    description: This GNU Radio flowgraph measures the delay between transmitted and leaked received signals in an FMCW radar setup. A VCO generates a chirp signal, which is transmitted and looped back. The received signal is mixed with the transmitted signal (Multiply Conjugate), and the resulting beat frequency is analyzed to estimate leakage-induced hardware delay.
    generate_options: qt_gui
    id: leakage_analysis
    output_language: python
    title: leakage_analysis
  states: {}

blocks:
- name: attenuation
  id: variable
  parameters:
    value: int(0)
  states: {}
- name: baseband_frequency
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: buffer_size
  id: variable
  parameters:
    value: int(32768)
  states: {}
- name: gain
  id: variable
  parameters:
    value: int(45)
  states: {}
- name: pi_
  id: variable
  parameters:
    value: pi
  states: {}
- name: rf_bandwidth
  id: variable
  parameters:
    value: int(10e6)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(6e6)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: baseband_frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/orkun-alp/Documents/fmcw_bitirme_calismalari/radar_parameter/dead_time_calc/chirp_leae_analysis_fiinishx.dat
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: 2*pi*1e6
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import time
      from gnuradio import gr

      class blk(gr.sync_block):  
          def __init__(self, duration=10):  
              gr.sync_block.__init__(
                  self, 
                  name='Timer',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.duration = duration
              self.pass_data = True

          def work(self, input_items, output_items):
              if not hasattr(self, "start_time"):
                  self.start_time = time.time()

              now = time.time()
              if now - self.start_time >= self.duration:
                  self.pass_data = False

              if self.pass_data:
                  output_items[0][:] = input_items[0]
                  return len(output_items[0])
              else:
                  return 0
    duration: '20'
  states: {state: disabled}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: attenuation
    bandwidth: rf_bandwidth
    buffer_size: buffer_size
    cyclic: 'True'
    filter_source: '''Auto'''
    frequency: '2400000000'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: rf_bandwidth
    bbdc: 'True'
    buffer_size: buffer_size
    filter_source: '''Auto'''
    frequency: '2400000000'
    gain1: '''manual'''
    manual_gain1: gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    name: '"tx_freq"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    name: '"rx_freq"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"tx_time"'
    size: '4096'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"rx_time"'
    size: '4096'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_vco_c_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', dc_blocker_xx_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_vco_c_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_vco_c_0, '0', iio_pluto_sink_0, '0']
- [blocks_vco_c_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vco_c_0, '0', qtgui_time_sink_x_0, '0']
- [dc_blocker_xx_0, '0', blocks_file_sink_0, '0']
- [iio_pluto_source_0, '0', blocks_multiply_conjugate_cc_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
